# Keil uVision project framework.uvprojx, settings and files
target SWM320 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.8.4
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: framework +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: .\build_ota_file.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM320_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM320_StdPeriph_Driver\CSL\SWM320_StdPeriph_Driver;.\APP;.\APP\FreeRTOS\include;.\APP\FreeRTOS\portable\RVDS\ARM_CM3;.\framework;.\APP\task;.\APP\work;.\APP\network;.\APP\cmdline;.\APP\led_board;.\APP\hlw8012;.\APP\message
  library: MicroLIB
  memory RVCT4: ROM 0x11800 size 0x16800
  memory RVCT9: RAM 0x20000000 size 0x20000
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
  group FreeRTOS\port
    ./APP/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./APP/FreeRTOS/portable/MemMang/: heap_4.c
  group CSL\StdPD
    ../../SWM320_StdPeriph_Driver/CSL/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_exti.c SWM320_gpio.c SWM320_i2c.c SWM320_pwm.c SWM320_timr.c SWM320_uart.c SWM320_wdt.c SWM320_dma.c SWM320_flash.c SWM320_port.c SWM320_spi.c SWM320_can.c SWM320_crc.c SWM320_lcd.c SWM320_rtc.c SWM320_sdio.c
  group CSL\CMSIS
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM320.c
    ../../SWM320_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
  group APP
    ./app/: main.c
  group app/task
    ./APP/task/: crtl_task.c listen_task.c start_task.c host_task.c
  group app/work
    ./APP/work/: work.c work.h work_data.c work_fuse.c work _deal_order.c work_cycle_reboot.c work_sock_ctrl.c work_debug.c
  group app/cmdline
    ./APP/cmdline/: cmdline.c cmdline.h
  group app/led_board
    ./APP/led_board/: led_board.c led_board.h
  group app/hlw8012
    ./APP/hlw8012/: hlw8012.h hlw80212.c
  group fk/driver
    ./framework/driver/: fk_drv_gpio.c fk_drv_uart.c fk_drv_rtc.c fk_drv_wdg.c
  group fk/driver_port
    ./framework/driver_port/: fk_drvp_gpio.c fk_drvp_uart.c fk_drvp_rtc.c fk_drvp_wdg.c
  group fk/lib_loopbuf
    ./framework/lib_loopbuf/: loopbuf.c
  group fk/lib_utc
    ./framework/lib_utc/: utc.c
  group fk/lib_fal/fal
    ./framework/lib_fal/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group fk/lib_fal/fal_port
    ./framework/lib_fal/fal_port/: fal_cfg.h fal_flash_swm320.c
  group fk/lib_stropt
    ./framework/lib_stropt/: stropt.c stropt.h
  group fk/lib_hc595
    ./framework/lib_hc595/: lib_hc595.c lib_hc595.h
  group network
    ./APP/network/: network.c network.h
  group network/air7xx
    ./APP/network/air7xx/: air7xx.c air7xx.h air7xx_base_opt.c air7xx_work_connect_serv.c air7xx_work_init_dev.c air7xx_work_rst_dev.c
  group app/message
    ./APP/message/: message.c message.h msg_cmd_analysis.c msg_ctrl_to_net.c msg_net_to_ctrl.c note.txt
